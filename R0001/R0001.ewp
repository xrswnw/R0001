# IAR project R0001.ewp, settings and files
configuration Build (ARM, debug)
  General.OGChipSelectEditMenu: GD32F103x8 GD GD32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _ANYID_HSE12P00_; _ANYID_BOOT_STM32_; _ANYID_STM32_
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\STM32_lib_V3.3\inc; ..\STM32_lib_V3.3\startup; ..\Otr_Lib\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: R0001.hex
  ILINK.IlinkOutputFile: R0001.out
  ILINK.IlinkIcfFile: GD32F103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    $EW_DIR$/arm/CMSIS/Core/Include/: core_cm3.h
    ../STM32_lib_V3.3/startup/: system_stm32f10x.c
  group EWARMv5
    ../STM32_lib_V3.3/startup/: startup_stm32f10x_hd.s
  group Main
    ../: main.c stm32f10x_conf.h stm32f10x_it.c
  group StdPeriph_Driver
    ../STM32_lib_V3.3/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c vssver2.scc
  group User
    ../Otr_Lib/src/: SW_Des.c SW_Stdlib.c
    ../src/: SW_FM17xx.c SW_FM17xx_HL.c SW_FM17xx_ISO14443A.c SW_FRam.c SW_R0001_Device.c SW_R0001_FRam.c SW_R0001_FRam_HL.c SW_R0001_R485.c SW_R0001_R485_HL.c SW_R0001_SysCfg.c SW_R0001_SysTick_HL.c SW_R0001_Uart.c SW_R0001_Uart_HL.c SW_R0001_WDG_HL.c SW_Uart_Receive.c
