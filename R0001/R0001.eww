<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Bootloader\R0001\Boot.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\R0001.ewp</path>
    </project>
    <batchBuild />
</workspace>
